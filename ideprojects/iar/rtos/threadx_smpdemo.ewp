# IAR project threadx_smpdemo.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: NX900 Nuclei NX900
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 3
  ICCRISCV.CCOptStrategy: 1
  ICCRISCV.CCDefines: RTOS_THREADX; SMP_CPU_CNT=2
  ICCRISCV.CCIncludePath2: ..\..\..\NMSIS\Core\Include; ..\..\..\SoC\evalsoc\Board\nuclei_fpga_eval\Include; ..\..\..\SoC\evalsoc\Common\Include; ..\..\..\application\threadx\smpdemo; ..\..\..\OS\ThreadX\common_smp\inc; ..\..\..\OS\ThreadX\ports_smp\nuclei
  IASMRISCV.AsmIncludePath: ..\..\..\NMSIS\Core\Include; ..\..\..\SoC\evalsoc\Common\Include
  OBJCOPY.OOCOutputFile: threadx_smpdemo.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: threadx_smpdemo.out
  ILINK.IlinkConfigDefines: SMP_CPU_CNT=2
  ILINK.IlinkIcfFile: ..\..\..\application\threadx\smpdemo\iar_evalsoc_smp.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCDefines: NDEBUG
  group application
    ../../../application/threadx/smpdemo/: main.c tx_user.h
  group nuclei_sdk/NMSIS/Core/Include
    ../../../NMSIS/Core/Include/: core_compatiable.h core_feature_base.h core_feature_bitmanip.h core_feature_cache.h core_feature_cidu.h core_feature_dsp.h core_feature_eclic.h core_feature_fpu.h core_feature_plic.h core_feature_pma.h core_feature_pmp.h core_feature_spmp.h core_feature_timer.h core_feature_vector.h nmsis_bench.h nmsis_compiler.h nmsis_core.h nmsis_gcc.h nmsis_iar.h nmsis_version.h riscv_bits.h riscv_encoding.h
  group nuclei_sdk/OS/ThreadX/common_smp/inc
    ../../../OS/ThreadX/common_smp/inc/: tx_api.h tx_block_pool.h tx_byte_pool.h tx_event_flags.h tx_initialize.h tx_mutex.h tx_queue.h tx_semaphore.h tx_thread.h tx_timer.h tx_trace.h tx_user_sample.h
  group nuclei_sdk/OS/ThreadX/common_smp/src
    ../../../OS/ThreadX/common_smp/src/: tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_performance_info_get.c tx_block_pool_performance_system_info_get.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_performance_info_get.c tx_byte_pool_performance_system_info_get.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_performance_info_get.c tx_event_flags_performance_system_info_get.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_misra.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_performance_info_get.c tx_mutex_performance_system_info_get.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_performance_info_get.c tx_queue_performance_system_info_get.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_performance_info_get.c tx_semaphore_performance_system_info_get.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_performance_info_get.c tx_thread_performance_system_info_get.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_smp_core_exclude.c tx_thread_smp_core_exclude_get.c tx_thread_smp_current_state_set.c tx_thread_smp_debug_entry_insert.c tx_thread_smp_high_level_initialize.c tx_thread_smp_rebalance_execute_list.c tx_thread_smp_utilities.c tx_thread_stack_analyze.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_performance_info_get.c tx_timer_performance_system_info_get.c tx_timer_smp_core_exclude.c tx_timer_smp_core_exclude_get.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c tx_trace_buffer_full_notify.c tx_trace_disable.c tx_trace_enable.c tx_trace_event_filter.c tx_trace_event_unfilter.c tx_trace_initialize.c tx_trace_interrupt_control.c tx_trace_isr_enter_insert.c tx_trace_isr_exit_insert.c tx_trace_object_register.c tx_trace_object_unregister.c tx_trace_user_event_insert.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
  group nuclei_sdk/OS/ThreadX/ports/nuclei
    ../../../OS/ThreadX/ports_smp/nuclei/: port.c tx_port.h
  group nuclei_sdk/OS/ThreadX/ports/nuclei/iar
    ../../../OS/ThreadX/ports_smp/nuclei/iar/: context.S interrupt.S
  group nuclei_sdk/SoC/Board/nuclei_fpga_eval/Include
    ../../../SoC/evalsoc/Board/nuclei_fpga_eval/Include/: board_nuclei_fpga_eval.h nuclei_sdk_hal.h
  group nuclei_sdk/SoC/Board/nuclei_fpga_eval/Source/IAR
    ../../../application/threadx/smpdemo/: iar_evalsoc_smp.icf
  group nuclei_sdk/SoC/Common/Include
    ../../../SoC/evalsoc/Common/Include/: cpufeature.h evalsoc.h evalsoc_uart.h nuclei_sdk_soc.h system_evalsoc.h
  group nuclei_sdk/SoC/Common/Source
    ../../../SoC/evalsoc/Common/Source/: evalsoc_common.c system_evalsoc.c
  group nuclei_sdk/SoC/Common/Source/Drivers
    ../../../SoC/evalsoc/Common/Source/Drivers/: evalsoc_uart.c
  group nuclei_sdk/SoC/Common/Source/IAR
    ../../../SoC/evalsoc/Common/Source/IAR/: intexc_evalsoc.S startup.S startup_evalsoc.c
  group nuclei_sdk/SoC/Common/Source/Stubs/iardlib
    ../../../SoC/evalsoc/Common/Source/Stubs/iardlib/: stubs.c
