# IAR project ucosii_demo.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: N300 Nuclei N300
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 3
  ICCRISCV.CCOptStrategy: 1
  ICCRISCV.CCDefines: RTOS_UCOSII
  ICCRISCV.CCIncludePath2: ..\..\..\NMSIS\Core\Include; ..\..\..\SoC\evalsoc\Board\nuclei_fpga_eval\Include; ..\..\..\SoC\evalsoc\Common\Include; ..\..\..\application\ucosii\demo; ..\..\..\OS\UCOSII\source; ..\..\..\OS\UCOSII\arch
  IASMRISCV.AsmIncludePath: ..\..\..\NMSIS\Core\Include
  OBJCOPY.OOCOutputFile: ucosii_demo.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: ucosii_demo.out
  ILINK.IlinkIcfFile: ..\..\..\SoC\evalsoc\Board\nuclei_fpga_eval\Source\IAR\iar_evalsoc_ilm.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCDefines: NDEBUG
  group application
    ../../../application/ucosii/demo/: app_cfg.h app_hooks.c main.c os_cfg.h
  group nuclei_sdk/NMSIS/Core/Include
    ../../../NMSIS/Core/Include/: core_compatiable.h core_feature_base.h core_feature_bitmanip.h core_feature_cache.h core_feature_cidu.h core_feature_dsp.h core_feature_eclic.h core_feature_fpu.h core_feature_pmp.h core_feature_spmp.h core_feature_timer.h core_feature_vector.h nmsis_bench.h nmsis_compiler.h nmsis_core.h nmsis_gcc.h nmsis_iar.h nmsis_version.h riscv_bits.h riscv_encoding.h
  group nuclei_sdk/OS/UCOSII/arch
    ../../../OS/UCOSII/arch/: os_cpu.h os_cpu_c.c os_cpu_port.c os_cpu_port.h
  group nuclei_sdk/OS/UCOSII/arch/iar
    ../../../OS/UCOSII/arch/iar/: os_cpu_a.S
  group nuclei_sdk/OS/UCOSII/source
    ../../../OS/UCOSII/source/: os.h os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_trace.h ucos_ii.h
  group nuclei_sdk/SoC/Board/nuclei_fpga_eval/Include
    ../../../SoC/evalsoc/Board/nuclei_fpga_eval/Include/: board_nuclei_fpga_eval.h nuclei_sdk_hal.h
  group nuclei_sdk/SoC/Board/nuclei_fpga_eval/Source/IAR
    ../../../SoC/evalsoc/Board/nuclei_fpga_eval/Source/IAR/: iar_evalsoc_ilm.icf
  group nuclei_sdk/SoC/Common/Include
    ../../../SoC/evalsoc/Common/Include/: evalsoc.h evalsoc_uart.h nuclei_sdk_soc.h system_evalsoc.h
  group nuclei_sdk/SoC/Common/Source
    ../../../SoC/evalsoc/Common/Source/: evalsoc_common.c system_evalsoc.c
  group nuclei_sdk/SoC/Common/Source/Drivers
    ../../../SoC/evalsoc/Common/Source/Drivers/: evalsoc_uart.c
  group nuclei_sdk/SoC/Common/Source/IAR
    ../../../SoC/evalsoc/Common/Source/IAR/: intexc_evalsoc.S startup_evalsoc.c
  group nuclei_sdk/SoC/Common/Source/Stubs/iardlib
    ../../../SoC/evalsoc/Common/Source/Stubs/iardlib/: stubs.c
