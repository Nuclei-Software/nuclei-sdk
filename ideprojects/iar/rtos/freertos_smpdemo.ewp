# IAR project freertos_smpdemo.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: NX900 Nuclei NX900
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 3
  ICCRISCV.CCOptStrategy: 1
  ICCRISCV.CCDefines: configNUMBER_OF_CORES=2; SMP_CPU_CNT=2
  ICCRISCV.CCIncludePath2: ..\..\..\NMSIS\Core\Include; ..\..\..\SoC\evalsoc\Board\nuclei_fpga_eval\Include; ..\..\..\SoC\evalsoc\Common\Include; ..\..\..\application\freertos\smpdemo; ..\..\..\OS\FreeRTOS\Source\include; ..\..\..\OS\FreeRTOS\Source\portable
  IASMRISCV.AsmIncludePath: ..\..\..\NMSIS\Core\Include
  OBJCOPY.OOCOutputFile: freertos_smpdemo.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: freertos_smpdemo.out
  ILINK.IlinkConfigDefines: SMP_CPU_CNT=2
  ILINK.IlinkIcfFile: ..\..\..\application\freertos\smpdemo\iar_evalsoc_smp.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCDefines: NDEBUG
  group application
    ../../../application/freertos/smpdemo/: FreeRTOConfig.h main.c
  group nuclei_sdk/NMSIS/Core/Include
    ../../../NMSIS/Core/Include/: core_compatiable.h core_feature_base.h core_feature_bitmanip.h core_feature_cache.h core_feature_cidu.h core_feature_dsp.h core_feature_eclic.h core_feature_fpu.h core_feature_pmp.h core_feature_spmp.h core_feature_timer.h core_feature_vector.h nmsis_bench.h nmsis_compiler.h nmsis_core.h nmsis_gcc.h nmsis_iar.h nmsis_version.h riscv_bits.h riscv_encoding.h
  group nuclei_sdk/OS/FreeRTOS/Source
    ../../../OS/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group nuclei_sdk/OS/FreeRTOS/Source/include
    ../../../OS/FreeRTOS/Source/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group nuclei_sdk/OS/FreeRTOS/Source/Portable
    ../../../OS/FreeRTOS/Source/portable/: port.c portmacro.h
  group nuclei_sdk/OS/FreeRTOS/Source/Portable/IAR
    ../../../OS/FreeRTOS/Source/portable/IAR/: portasm.S
  group nuclei_sdk/OS/FreeRTOS/Source/Portable/MemMang
    ../../../OS/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group nuclei_sdk/SoC/Board/nuclei_fpga_eval/Include
    ../../../SoC/evalsoc/Board/nuclei_fpga_eval/Include/: board_nuclei_fpga_eval.h nuclei_sdk_hal.h
  group nuclei_sdk/SoC/Board/nuclei_fpga_eval/Source/IAR
    ../../../application/freertos/smpdemo/: iar_evalsoc_smp.icf
  group nuclei_sdk/SoC/Common/Include
    ../../../SoC/evalsoc/Common/Include/: evalsoc.h evalsoc_uart.h nuclei_sdk_soc.h system_evalsoc.h
  group nuclei_sdk/SoC/Common/Source
    ../../../SoC/evalsoc/Common/Source/: evalsoc_common.c system_evalsoc.c
  group nuclei_sdk/SoC/Common/Source/Drivers
    ../../../SoC/evalsoc/Common/Source/Drivers/: evalsoc_uart.c
  group nuclei_sdk/SoC/Common/Source/IAR
    ../../../SoC/evalsoc/Common/Source/IAR/: intexc_evalsoc.S startup.S startup_evalsoc.c
  group nuclei_sdk/SoC/Common/Source/Stubs/iardlib
    ../../../SoC/evalsoc/Common/Source/Stubs/iardlib/: stubs.c
