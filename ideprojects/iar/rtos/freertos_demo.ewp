# IAR project freertos_demo.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: N200 Nuclei N200
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 3
  ICCRISCV.CCOptStrategy: 1
  ICCRISCV.CCIncludePath2: ..\..\..\NMSIS\Core\Include; ..\..\..\SoC\evalsoc\Board\nuclei_fpga_eval\Include; ..\..\..\SoC\evalsoc\Common\Include; ..\..\..\application\freertos\demo; ..\..\..\OS\FreeRTOS\Source\include; ..\..\..\OS\FreeRTOS\Source\portable
  IASMRISCV.AsmIncludePath: ..\..\..\NMSIS\Core\Include
  OBJCOPY.OOCOutputFile: freertos_demo.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: freertos_demo.out
  ILINK.IlinkIcfFile: ..\..\..\SoC\evalsoc\Board\nuclei_fpga_eval\Source\IAR\iar_evalsoc_ilm.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCDefines: NDEBUG
  group application
    ../../../application/freertos/demo/: FreeRTOConfig.h main.c
  group nuclei_sdk/NMSIS/Core/Include
    ../../../NMSIS/Core/Include/: core_compatiable.h core_feature_base.h core_feature_irqc.h core_feature_timer.h nmsis_bench.h nmsis_compiler.h nmsis_core.h nmsis_gcc.h nmsis_iar.h nmsis_version.h riscv_bits.h riscv_encoding.h
  group nuclei_sdk/OS/FreeRTOS/Source
    ../../../OS/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group nuclei_sdk/OS/FreeRTOS/Source/include
    ../../../OS/FreeRTOS/Source/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group nuclei_sdk/OS/FreeRTOS/Source/Portable
    ../../../OS/FreeRTOS/Source/portable/: port.c portmacro.h
  group nuclei_sdk/OS/FreeRTOS/Source/Portable/IAR
    ../../../OS/FreeRTOS/Source/portable/IAR/: portasm.S
  group nuclei_sdk/OS/FreeRTOS/Source/Portable/MemMang
    ../../../OS/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group nuclei_sdk/SoC/Board/nuclei_fpga_eval/Include
    ../../../SoC/evalsoc/Board/nuclei_fpga_eval/Include/: board_nuclei_fpga_eval.h nuclei_sdk_hal.h
  group nuclei_sdk/SoC/Board/nuclei_fpga_eval/Source/IAR
    ../../../SoC/evalsoc/Board/nuclei_fpga_eval/Source/IAR/: iar_evalsoc_ilm.icf
  group nuclei_sdk/SoC/Common/Include
    ../../../SoC/evalsoc/Common/Include/: evalsoc.h evalsoc_uart.h nuclei_sdk_soc.h system_evalsoc.h
  group nuclei_sdk/SoC/Common/Source
    ../../../SoC/evalsoc/Common/Source/: evalsoc_common.c system_evalsoc.c
  group nuclei_sdk/SoC/Common/Source/Drivers
    ../../../SoC/evalsoc/Common/Source/Drivers/: evalsoc_uart.c
  group nuclei_sdk/SoC/Common/Source/IAR
    ../../../SoC/evalsoc/Common/Source/IAR/: intexc_evalsoc.S startup_evalsoc.c
  group nuclei_sdk/SoC/Common/Source/Stubs/iardlib
    ../../../SoC/evalsoc/Common/Source/Stubs/iardlib/: stubs.c
