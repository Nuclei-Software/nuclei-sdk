<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\baremetal\coremark.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\baremetal\dhrystone.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\baremetal\whetstone.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\baremetal\demo_timer.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\baremetal\demo_irqc.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\baremetal\helloworld.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\baremetal\lowpower.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\baremetal\demo_extirq.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\rtos\freertos_demo.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\rtos\rtthread_demo.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\rtos\rtthread_msh.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\rtos\ucosii_demo.ewp</path>
    </project>
    <batchBuild />
</workspace>
