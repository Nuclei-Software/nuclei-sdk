# IAR project demo_dsp.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: N300 Nuclei N300
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 3
  ICCRISCV.CCOptStrategy: 1
  ICCRISCV.CCIncludePath2: ..\..\..\NMSIS\Core\Include; ..\..\..\NMSIS\DSP\Include; ..\..\..\NMSIS\DSP\PrivateInclude; ..\..\..\SoC\evalsoc\Board\nuclei_fpga_eval\Include; ..\..\..\SoC\evalsoc\Common\Include; ..\..\..\application\baremetal\demo_dsp
  IASMRISCV.AsmIncludePath: ..\..\..\NMSIS\Core\Include; ..\..\..\SoC\evalsoc\Common\Include
  OBJCOPY.OOCOutputFile: demo_dsp.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: demo_dsp.out
  ILINK.IlinkIcfFile: ..\..\..\SoC\evalsoc\Board\nuclei_fpga_eval\Source\IAR\iar_evalsoc_ilm.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\NMSIS\Library\DSP\GCC\libnmsis_dsp_rv32imafdc.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCDefines: NDEBUG
  group application
    ../../../application/baremetal/demo_dsp/: main.c math_helper.c ref_conv.c ref_conv.h ref_helper.c
  group nuclei_sdk/NMSIS/Core/Include
    ../../../NMSIS/Core/Include/: core_compatiable.h core_feature_base.h core_feature_bitmanip.h core_feature_cache.h core_feature_cidu.h core_feature_dsp.h core_feature_eclic.h core_feature_fpu.h core_feature_plic.h core_feature_pma.h core_feature_pmp.h core_feature_spmp.h core_feature_timer.h core_feature_vector.h nmsis_bench.h nmsis_compiler.h nmsis_core.h nmsis_gcc.h nmsis_iar.h nmsis_version.h riscv_bits.h riscv_encoding.h
  group nuclei_sdk/SoC/Board/nuclei_fpga_eval/Include
    ../../../SoC/evalsoc/Board/nuclei_fpga_eval/Include/: board_nuclei_fpga_eval.h nuclei_sdk_hal.h
  group nuclei_sdk/SoC/Board/nuclei_fpga_eval/Source/IAR
    ../../../SoC/evalsoc/Board/nuclei_fpga_eval/Source/IAR/: iar_evalsoc_ilm.icf
  group nuclei_sdk/SoC/Common/Include
    ../../../SoC/evalsoc/Common/Include/: cpufeature.h evalsoc.h evalsoc_uart.h nuclei_sdk_soc.h system_evalsoc.h
  group nuclei_sdk/SoC/Common/Source
    ../../../SoC/evalsoc/Common/Source/: evalsoc_common.c system_evalsoc.c
  group nuclei_sdk/SoC/Common/Source/Drivers
    ../../../SoC/evalsoc/Common/Source/Drivers/: evalsoc_uart.c
  group nuclei_sdk/SoC/Common/Source/IAR
    ../../../SoC/evalsoc/Common/Source/IAR/: intexc_evalsoc.S startup_evalsoc.c
  group nuclei_sdk/SoC/Common/Source/Stubs/iardlib
    ../../../SoC/evalsoc/Common/Source/Stubs/iardlib/: stubs.c
