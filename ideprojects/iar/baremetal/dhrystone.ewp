# IAR project dhrystone.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: N200 Nuclei N200
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 3
  ICCRISCV.CCOptStrategy: 2
  ICCRISCV.CCIncludePath2: ..\..\..\NMSIS\Core\Include; ..\..\..\SoC\evalsoc\Board\nuclei_fpga_eval\Include; ..\..\..\SoC\evalsoc\Common\Include; ..\..\..\application\baremetal\benchmark\dhrystone
  IASMRISCV.AsmIncludePath: ..\..\..\NMSIS\Core\Include; ..\..\..\SoC\evalsoc\Common\Include
  OBJCOPY.OOCOutputFile: dhrystone.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: dhrystone.out
  ILINK.IlinkIcfFile: ..\..\..\SoC\evalsoc\Board\nuclei_fpga_eval\Source\IAR\iar_evalsoc_sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCDefines: NDEBUG
  group application
    ../../../application/baremetal/benchmark/dhrystone/: dhry.h dhry_1.c dhry_2.c dhry_stubs.c
  group nuclei_sdk/NMSIS/Core/Include
    ../../../NMSIS/Core/Include/: core_compatiable.h core_feature_base.h core_feature_irqc.h core_feature_timer.h nmsis_bench.h nmsis_compiler.h nmsis_core.h nmsis_gcc.h nmsis_iar.h nmsis_version.h riscv_bits.h riscv_encoding.h
  group nuclei_sdk/SoC/Board/nuclei_fpga_eval/Include
    ../../../SoC/evalsoc/Board/nuclei_fpga_eval/Include/: board_nuclei_fpga_eval.h nuclei_sdk_hal.h
  group nuclei_sdk/SoC/Board/nuclei_fpga_eval/Source/IAR
    ../../../SoC/evalsoc/Board/nuclei_fpga_eval/Source/IAR/: iar_evalsoc_sram.icf
  group nuclei_sdk/SoC/Common/Include
    ../../../SoC/evalsoc/Common/Include/: evalsoc.h cpufeature.h evalsoc_uart.h nuclei_sdk_soc.h system_evalsoc.h
  group nuclei_sdk/SoC/Common/Source
    ../../../SoC/evalsoc/Common/Source/: evalsoc_common.c system_evalsoc.c
  group nuclei_sdk/SoC/Common/Source/Drivers
    ../../../SoC/evalsoc/Common/Source/Drivers/: evalsoc_uart.c
  group nuclei_sdk/SoC/Common/Source/IAR
    ../../../SoC/evalsoc/Common/Source/IAR/: intexc_evalsoc.S startup.S startup_evalsoc.c
  group nuclei_sdk/SoC/Common/Source/Stubs/iardlib
    ../../../SoC/evalsoc/Common/Source/Stubs/iardlib/: stubs.c
